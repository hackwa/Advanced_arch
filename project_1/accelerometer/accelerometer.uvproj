# Keil uVision project accelerometer.uvproj, settings and files
target mbed FRDM-KL25Z (5060020::V5.06 (build 20)::ARMCC)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: accelerometer
  AfterMake: fromelf --bin -o build\accelerometer_KL25Z.bin build\accelerometer.axf
  c flags: Optim=1
  c define: TARGET_FF_ARDUINO,  TARGET_KLXX,  TARGET_KL25Z,  MBED_BUILD_TIMESTAMP=1442244279.25,  TARGET_CORTEX_M,  TARGET_M0P,  TARGET_Freescale,  __MBED__=1,  __CORTEX_M0PLUS,  TOOLCHAIN_ARM,  TOOLCHAIN_ARM_STD,  ARM_MATH_CM0PLUS,  __ASSERT_MSG,
  c misc: --gnu --no_rtti
  c include: .;  MMA8451Q;  mbed;  mbed/KL25Z;  mbed/KL25Z/ARM
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: mbed/KL25Z/ARM/MKL25Z4.sct
  link misc: mbed/KL25Z/ARM/sys.o
            
              mbed/KL25Z/ARM/core_cm0.o
            
              mbed/KL25Z/ARM/system_MKL25Z4.o
            
              mbed/KL25Z/ARM/cmsis_nvic.o
            
              mbed/KL25Z/ARM/startup_MKL25Z4.o
            
              mbed/KL25Z/ARM/mbed.ar
  group src
    ./: main.cpp
    MMA8451Q/: MMA8451Q.cpp
